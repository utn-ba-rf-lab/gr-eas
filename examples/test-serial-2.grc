options:
  parameters:
    generate_options: qt_gui
    id: test_serial
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: valor
  id: variable_qtgui_range
  parameters:
    label: Valor
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: valor
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    type: float
  states: {}
- name: serializer_serializer_0
  id: serializer_serializer
  parameters:
    device: /dev/ttyUSB1
    mode: detector
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_number_sink_0, '0']
- [analog_const_source_x_0, '0', serializer_serializer_0, '0']

metadata:
  file_format: 1
