options:
  parameters:
    catch_exceptions: 'False'
    generate_options: qt_gui
    id: test_serial
    output_language: python
    realtime_scheduling: '1'
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: valor
  id: variable_qtgui_range
  parameters:
    label: Valor
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '0'
    widget: slider
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: valor
    freq: '.5'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1, -1, 1, -1)
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    type: float
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: serializer_serializer_0
  id: serializer_serializer
  parameters:
    board: 'True'
    device: /dev/ttyUSB1
    mode: detector
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', serializer_serializer_0, '0']

metadata:
  file_format: 1
