options:
  parameters:
    generate_options: qt_gui
    id: test_serial
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: (-1, 5, -8,-3,1,2,3)
  states: {}
- name: eas_eas_0
  id: eas_eas
  parameters:
    board: 'False'
    device: '"/dev/ttyUSB1"'
    input_type: float
    mode: detector
    samp_rate: samp_rate
    vref: '4.096'
  states: {}

connections:
- [blocks_throttle_0, '0', eas_eas_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
