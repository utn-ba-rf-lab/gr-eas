options:
  parameters:
    generate_options: qt_gui
    id: test_serial
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: (-1, 5, -8,-3,1,2,3)
  states: {}
- name: serializer_serializer_0
  id: serializer_serializer
  parameters:
    device: /dev/ttyUSB1
    mode: detector
  states: {}

connections:
- [blocks_throttle_0, '0', serializer_serializer_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
